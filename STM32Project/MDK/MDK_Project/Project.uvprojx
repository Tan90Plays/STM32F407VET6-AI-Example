# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Lib\inc;..\Lib\cmsis;..\User\ai;..\User\ai\st_ai\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Lib/starup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../Lib/cmsis/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../User/: delay.c main.c stm32f4xx_it.c usart.c
  group Text
    ../: text.txt
  group lib
    ../Lib/AI/: NetworkRuntime1020_CM4_Keil.lib
  group ST_AI
    ../User/ai/st_ai/Inc/: ai_common_config.h ai_datatypes.h ai_datatypes_defines.h ai_datatypes_format.h ai_datatypes_internal.h ai_layer_custom_interface.h ai_lite.h ai_lite_inspect.h ai_lite_interface.h ai_lite_math_helpers.h ai_math_helpers.h ai_platform.h ai_platform_interface.h core_assert.h core_common.h core_convert.h core_datatypes.h core_log.h core_net_inspect.h core_net_inspect_interface.h core_private.h datatypes_network.h formats_list.h layers.h layers_argminmax.h layers_common.h layers_conv2d.h layers_conv2d_dqnn.h layers_custom.h layers_dense.h layers_dense_dqnn.h layers_formats_converters.h layers_generic.h layers_generic_dqnn.h layers_list.h layers_lite_graph.h layers_ml.h layers_ml_iforest.h layers_ml_linearclassifier.h layers_ml_svc.h layers_ml_svmregressor.h layers_ml_treeensembleclassifier.h layers_ml_treeensembleregressor.h layers_nl.h layers_norm.h layers_pad_dqnn.h layers_pad_generic.h layers_pool.h layers_pool_dqnn.h layers_resize.h layers_rnn.h layers_sm.h layers_upsample.h layers_upsample_generic.h layers_wrappers.h lite_argminmax.h lite_bn_f32.h lite_bn_integer.h lite_conv2d.h lite_conv2d_dqnn.h lite_conv2d_is16.h lite_conv2d_sssa8_ch.h lite_convert_dqnn.h lite_dense_if32.h lite_dense_is1.h lite_dense_is1ws1.h lite_dense_is8os1ws1.h lite_dense_is8os8ws8.h lite_dense_is16.h lite_dense_ws1.h lite_dw.h lite_dw_dqnn.h lite_generic_float.h lite_gru_f32.h lite_internal_apis.h lite_lstm.h lite_maxpool_dqnn.h lite_nl_generic_integer.h lite_nl_list.h lite_norm_f32.h lite_operators.h lite_pad_dqnn.h lite_pad_generic.h lite_pool_f32.h lite_pool_is8os8.h lite_pw.h lite_pw_dqnn.h lite_resize.h lite_upsample.h lite_upsample_generic.h stai.h stai_debug.h stai_events.h
  group AI
    ../User/ai/: network.c network.h network_config.h network_data.c network_data.h network_data_params.c network_data_params.h
